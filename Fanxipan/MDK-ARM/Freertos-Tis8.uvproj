# Keil uVision project Freertos-Tis8.uvproj, settings and files
target stm32f4_blink_freertos (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F407VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: project.hex +hex
  c flags: v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F4XX,HSE_VALUE=8000000
  c include: ..\;..\CMSIS\Include;..\CMSIS\STM32F4xx\Include;..\STM32F4_Discovery;..\STM32F4xx_StdPeriph_Driver\inc;..\startup;..\FreeRTOS\Source\include;..\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\FreeRTOS;..\00-STM32F429_LIBRARIES;..\00-STM32F429_LIBRARIES\lwip;..\00-STM32F429_LIBRARIES\lwip\port;..\00-STM32F429_LIBRARIES\lwip\src\include\ipv4;..\00-STM32F429_LIBRARIES\lwip\src\include\netif;..\00-STM32F429_LIBRARIES\lwip\src\include\lwip;..\00-STM32F429_LIBRARIES\lwip\src\include;..\FreeRTOS\Source;..\00-STM32F429_LIBRARIES\fatfs;..\00-STM32F429_LIBRARIES\fatfs\drivers;..\00-STM32F429_LIBRARIES\fatfs\option
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group main
    ../: main.c stm32f4xx_conf.h stm32f4xx_it.c defines.h
    ../startup/: system_stm32f4xx.c
  group STM32F4xx_StdPeriph_Driver
    ../STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_gpio.c stm32f4xx_exti.c stm32f4xx_rcc.c misc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_dma.c stm32f4xx_sdio.c stm32f4xx_rtc.c stm32f4xx_pwr.c
  group Discovery
    ../STM32F4_Discovery/: discoveryf4utils.c
  group FreeRTOS
    ../FreeRTOS/Source/: tasks.c queue.c list.c croutine.c timers.c
    ../FreeRTOS/Source/portable/MemMang/: heap_2.c
    ../FreeRTOS/: FreeRTOSConfig.h
    ../FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group startup
    ../startup/: startup_stm32f4xx.s system_stm32f4xx.c
  group CMSIS
    ../CMSIS/STM32F4xx/Include/: stm32f4xx.h system_stm32f4xx.h
    ../STM32F4xx_StdPeriph_Driver/inc/: misc.h stm32f4xx_dma.h stm32f4xx_gpio.h stm32f4xx_rcc.h stm32f4xx_sdio.h stm32f4xx_tim.h stm32f4xx_usart.h stm32f4xx_adc.h stm32f4xx_pwr.h stm32f4xx_spi.h stm32f4xx_rtc.h stm32f4xx_syscfg.h stm32f4xx_iwdg.h stm32f4xx_exti.h
  group TM
    ../00-STM32F429_LIBRARIES/: tm_stm32f4_hd44780.c tm_stm32f4_gpio.c tm_stm32f4_usart.c tm_stm32f4_ethernet.c tm_stm32f4_rcc.c tm_stm32f4_delay.c tm_stm32f4_watchdog.c tm_stm32f4_exti.c tm_stm32f4_fatfs.c tm_stm32f4_rtc.c tm_stm32f4_bkpsram.c tm_stm32f4_bkpsram.h
  group Ethernet
    ../00-STM32F429_LIBRARIES/lwip/: netconf.c stm32f4x7_eth.c stm32f4x7_eth_bsp.c
    ../00-STM32F429_LIBRARIES/lwip/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../00-STM32F429_LIBRARIES/lwip/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    ../00-STM32F429_LIBRARIES/lwip/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../00-STM32F429_LIBRARIES/lwip/src/netif/: etharp.c ethernetif.c slipif.c
    ../00-STM32F429_LIBRARIES/lwip/port/: ethernetif.h
  group Ethernet Client
    ../00-STM32F429_LIBRARIES/lwip/: tcp_echoclient.c tcp_echoclient.h
  group Ethernet Server
    ../00-STM32F429_LIBRARIES/lwip/: fs.c fs.h fsdata.c fsdata.h httpd.c httpd.h httpd_structs.h
  group FatFs
    ../00-STM32F429_LIBRARIES/fatfs/: diskio.c diskio.h ff.c ff.h ffconf.h integer.h
    ../00-STM32F429_LIBRARIES/fatfs/option/: syscall.c unicode.c
    ../00-STM32F429_LIBRARIES/fatfs/drivers/: fatfs_sd_sdio.c fatfs_sd_sdio.h
